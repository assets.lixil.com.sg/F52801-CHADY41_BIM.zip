Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-10T21:37:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 10 21:37:46 2022 * Host: DESKTOP-D2DSTPK * Database: C:\Users\WINDOWS\AppData\Local\Temp\1b322e85-d7c1-431e-bb71-9a1488ba07a6\6afb1f90-8612-4b1d-8839-0236a06e61b1\ifc * Database version: 5507 * Database creation date: Thu Nov 10 21:37:45 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 10 21:37:45 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 10 21:37:45 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: F52801-CHADY41:Concept round robe hook AS, F52801-CHADY41:Concept round robe hook AS:348229
In: Level 1
Material: Brass
Pset_DistributionFlowElementCommon - Reference: Concept round robe hook AS; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
